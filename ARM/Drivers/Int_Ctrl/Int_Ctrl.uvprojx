# Keil uVision project Int_Ctrl.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Int_Ctrl
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=4
  c include: .\Src\Common;.\Src\Config;.\Src\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Config
    ./Src/Config/: IntCtrl_Lcfg.c
  group Appl
    ./Src/Appl/: main.c
  group Mcal
    ./Src/Mcal/: IntCtrl.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
